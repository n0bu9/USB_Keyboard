# Keil uVision project CH554.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\main;..\Public
  group Main
    ../main/: GPIO.C Main.C timer.c
  group Public
    ../Public/: Debug.C
