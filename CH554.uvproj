# Keil uVision project CH554.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\main;.\Public;.\hal
  link misc: REMOVEUNUSED
  group Main
    ./main/: gpio.c keyboard.c main.c basic.c iap.c usb_hid.c
  group Public
    ./Public/: Debug.C CH554.H
  group Core
    ./hal/: ch55x_gpio.c ch55x_timer.c ch55x_uart.c system_ch55x.c
